# Keil uVision project MotionSensor.uvprojx, settings and files
target MotionSensor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MotionSensor
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\LIB;.\madgwick_algorithm_C\MadgwickAHRS;.\madgwick_algorithm_C\MahonyAHRS;.\LIB\HC-05;.\LIB\RTC STM32F103;..\Project ONE;.\LIB\BMI160;.\LIB\BMM150-Sensor-API-master
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group
    ./: Main.c Main.h stm32f10x_Inits.c Menu.c Menu.h IRQ_Handlers.c stm32f10x_Inits.h IRQ_Handlers.h
    ./LIB/: stm32_delay_asm.c
  group BMI160
    ./LIB/BMI160/: bmi160.c bmi160.h bmi160_defs.h
    ./: BMI160_func.c BMI160_func.h
  group Madgwick filter
    ./madgwick_algorithm_C/MadgwickAHRS/: MadgwickAHRS.c MadgwickAHRS.h
  group HC-05
    ./LIB/HC-05/: HC-05.c HC-05.h
  group RTC_init
    ./LIB/RTC STM32F103/: RTC_init.c RTC_init.h
  group BMM150
    ./LIB/BMM150-Sensor-API-master/: bmm150.c bmm150.h bmm150_defs.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
